# Keil uVision project S-230_APP.uvprojx, settings and files
target S-230_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: S-230_APP +hex
  BeforeMake: .\S-230_APP\before_keil.bat
  AfterMake: fromelf --bin --output  .\S-230_APP\S-230_APP.bin  .\S-230_APP\S-230_APP.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=english
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../APP;../BSP;../Common;../AT_Parser;../Hardware;../Protocol;../RS485;..\MODBUS;..\User_Protocol
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\S-230_APP\S-230_APP.sct
  group APP
    ../APP/: app.c app_config.c app_logo.c app_pump.c app_task.c app_network.c app_protocol.c app_sensors.c app_l6.c app_update_firmware.c app_gprs.c app_relay.c app_environment.c app_status.c app_lcd.c
  group Hardware
    ../Hardware/: gpio_at24cxx.c gpio_iic.c onewire.c stm32_flash.c l6.c gpio_aht20.c lcd_driver.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_hal.c bsp_log.c bsp_rs485.c bsp_usart.c bsp_pump.c bsp_mcu.c bsp_wdg.c bsp_protocol.c bsp_at24cm1.c bsp_rtc.c bsp_aht20.c bsp_lcd.c
  group Protocol
    ../Protocol/: g2_server_slave.c g2_server_packet.c g2_server_message.c
  group Common
    ../Common/: dwt_delay.c utils.c water_indicator.c datetime_utils.c config_bit.c mean_filter.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: gpio.c dma.c iwdg.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c adc.c spi.c
  group MODBUS
    ../MODBUS/: modbus_master.c modbus_message.c modbus_packet.c
  group RS485
    ../RS485/: rs485.c rs485_l6.c rs485_sensor.c
    ../RS485/drivers/sensors/: sensors.c
    ../RS485/drivers/sensors/zyiot/: doy100.c ph201.c do_default.c
    ../RS485/drivers/sensors/szklt/: ph230.c
    ../RS485/drivers/sensors/probest/: doy121.c
    ../RS485/drivers/sensors/five_phase/: doy170.c
    ../RS485/drivers/sensors/anbuleila/: wl991.c
    ../RS485/drivers/sensors/chemins/: ph260.c
    ../RS485/drivers/sensors/xiantao/: doy181.c ph291.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group UserProtocol
    ../User_Protocol/: user_protocol_master.c user_protocol_message.c user_protocol_packet.c
software components: CMSIS:CORE 4.3.0
